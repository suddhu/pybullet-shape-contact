Commit message: modifying physical params

File: models/shapes/rect1.urdf (robot description, URDF)
Before this commit: robot rect1, 1 links, 0 joints
Links:
- link rect1_base_link: mass 0.8374 -> 10.8374
