Commit message: reorganized models

File: models/shapes/rect.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- removed link block_2_base_link
- added link rect_base_link, mass 2.0; collision box size=0.10 0.10 0.05; visual box size=0.10 0.10 0.05
