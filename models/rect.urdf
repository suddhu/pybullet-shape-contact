Commit message: modified friction vals, real time simulator, shape dimensions changed

File: models/rect.urdf (robot description, URDF)
Before this commit: robot rect, 1 links, 0 joints
Links:
- link rect_base_link: mass 0.837 -> 2.0
